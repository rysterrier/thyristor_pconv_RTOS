# Keil uVision project master_v1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: master_v1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, USE_FULL_LL_DRIVER, _RTE_, STM32F303xC
  c include: ..\Sources\App\inc;..\Sources\Common\inc;..\Sources\Drivers\STM32F30x_StdPeriph_Driver\inc;..\Sources\FreeRTOS\inc;..\Sources\gsm_at_lib\src\include;..\Sources\gsm_at_lib\src\include\system\port\cmsis_os;..\Sources\gsm_at_lib\snippets\include;..\Sources\sim800\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group App
    ../Sources/App/src/: adc.c sw_ctrl.c sw_ll_ctrl.c uart4.c
  group FreeRTOS
    ../Sources/FreeRTOS/src/: rtos.c
  group Common
    ../Sources/Common/src/: main.c periph.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group STM32F30x_StdPeriph
    ../Sources/Drivers/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dma.c
  group SIM800
    ../Sources/sim800/src/: sim800.c
software components: RTOS:Config 10.2.1, RTOS:Core 10.2.1, RTOS:Event Groups 10.2.1, RTOS:Heap 10.2.1, RTOS:Timers 10.2.1, CMSIS:CORE 5.4.0, CMSIS:RTOS2:FreeRTOS 10.2.1, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL:COMMON 1.9.0, Device:STM32Cube HAL:CORTEX 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:FLASH 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:TIM 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:STM32Cube HAL:USART 1.9.0, Device:STM32Cube LL:COMMON 1.9.0, Device:STM32Cube LL:DMA 1.9.0, Device:STM32Cube LL:GPIO 1.9.0, Device:STM32Cube LL:PWR 1.9.0, Device:STM32Cube LL:RCC 1.9.0, Device:STM32Cube LL:TIM 1.9.0, Device:STM32Cube LL:USART 1.9.0, Device:STM32Cube LL:UTILS 1.9.0, Device:Startup 1.0.0
